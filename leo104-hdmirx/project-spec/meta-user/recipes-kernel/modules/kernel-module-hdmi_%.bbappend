SRC_URI_append = " \
"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
